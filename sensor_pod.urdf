Commit message: updating sensor_pod

File: sensor_pod.urdf (robot description, URDF)
Before this commit: robot sensor_pod, 1 links, 0 joints
Links:
- link pod: geometry collision box size=0.1 0.1 0.1; visual box size=0.1 0.1 0.1
